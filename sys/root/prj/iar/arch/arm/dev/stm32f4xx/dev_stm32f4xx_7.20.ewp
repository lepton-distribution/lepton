# IAR project dev_stm32f4xx_7.20.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: LM3SxDxx TexasInstruments LM3SxDxx
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: ewarm; OS_SUPPORT_CLEANUP_ON_TERMINATE; OS_LIBMODE_SP; _OS_LIBMODE_DT; _OS_LIBMODE_R; NDEBUG; USE_STDPERIPH_DRIVER
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: c:/tauon/sys/root/src/kernel/core/ucore/freeRTOS_8-0-0/source/include; c:/tauon/sys/root/src/kernel/core/ucore/freeRTOS_8-0-0/source/portable/IAR/ARM_CM4F; c:/tauon/sys/root/src/kernel/core/ucore/embOSCXM4_386/inc; c:/tauon/sys/root/src/kernel/core/ucore/embOSCXM3_382/inc; c:/tauon/sys/root/src/kernel/core/ucore/cmsis/CMSIS/Include; c:/tauon/sys/root/src; c:/tauon/sys/root/src/kernel/net/lwip; c:/tauon/sys/root/src/kernel/net/lwip/include; c:/tauon/sys/root/src/kernel/net/lwip/ports/arm; c:/tauon/sys/root/src/kernel/net/lwip/ports/arm/include; c:/tauon/sys/root/src/kernel/net/lwip/include/ipv4; c:/tauon/sys/root/src/kernel/fs/yaffs/core; c:/tauon/sys/root/src/kernel/fs/yaffs/core/direct; c:/tauon/sys/root/src/kernel/net/uip2.5
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: ewarm
  OBJCOPY.OOCOutputFile: driverlib.srec
  ILINK.IlinkOutputFile: driverlib.out
  group kernel/dev/arch/cortexm/stm32f4xx
    ../../../../../../src/kernel/dev/arch/cortexm/stm32f4xx/: dma.h eth.c eth.h gpio.c gpio.h spi.c spi.h stm32f4x7_eth_conf.h target.c target.h types.h uart.c uart.h
  group kernel/dev/arch/cortexm/stm32f4xx/dev_stm32f4xx
    ../../../../../../src/kernel/dev/arch/cortexm/stm32f4xx/dev_stm32f4xx/: dev_stm32f4xx_eth.c dev_stm32f4xx_olimex_board.c dev_stm32f4xx_spi_3.c dev_stm32f4xx_spi_x.c dev_stm32f4xx_spi_x.h dev_stm32f4xx_uart_1.c dev_stm32f4xx_uart_6.c dev_stm32f4xx_uart_x.c dev_stm32f4xx_uart_x.h
  group kernel/dev/arch/cortexm/stm32f4xx/driverlib
    ../../../../../../src/kernel/dev/arch/cortexm/stm32f4xx/driverlib/: misc.c misc.h stm32f4x7_eth.c stm32f4x7_eth.h stm32f4x7_eth_conf_template.h stm32f4xx.h stm32f4xx_adc.c stm32f4xx_adc.h stm32f4xx_can.c stm32f4xx_can.h stm32f4xx_conf.h stm32f4xx_crc.c stm32f4xx_crc.h stm32f4xx_cryp.c stm32f4xx_cryp.h stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dac.h stm32f4xx_dbgmcu.c stm32f4xx_dbgmcu.h stm32f4xx_dcmi.c stm32f4xx_dcmi.h stm32f4xx_dma.c stm32f4xx_dma.h stm32f4xx_eth.c stm32f4xx_eth.h stm32f4xx_exti.c stm32f4xx_exti.h stm32f4xx_flash.c stm32f4xx_flash.h stm32f4xx_fsmc.c stm32f4xx_fsmc.h stm32f4xx_gpio.c stm32f4xx_gpio.h stm32f4xx_hash.c stm32f4xx_hash.h stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_i2c.h stm32f4xx_iwdg.c stm32f4xx_iwdg.h stm32f4xx_pwr.c stm32f4xx_pwr.h stm32f4xx_rcc.c stm32f4xx_rcc.h stm32f4xx_rng.c stm32f4xx_rng.h stm32f4xx_rtc.c stm32f4xx_rtc.h stm32f4xx_sdio.c stm32f4xx_sdio.h stm32f4xx_spi.c stm32f4xx_spi.h stm32f4xx_syscfg.c stm32f4xx_syscfg.h stm32f4xx_tim.c stm32f4xx_tim.h stm32f4xx_usart.c stm32f4xx_usart.h stm32f4xx_wwdg.c stm32f4xx_wwdg.h system_stm32f4xx.h
